# Keil uVision project STM32F103RC.uvprojx, settings and files
target STM32F103RC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Q2Max +hex
  AfterMake: fromelf --bin --output .\STM32F103RC\Q2Max.bin .\STM32F103RC\Q2Max.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\App\Inc;..\SYSTEM\sys;..\SYSTEM;..\SYSTEM\delay;..\HARDWARE;..\HARDWARE\FFT;..\HARDWARE\ADC;..\USE_INC;..\zhouyu_Src;..\SYSTEM\job
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c ringbuffer.c multi_button.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ../App/Src/: WS2812.c globaldata.c globalfunc.c APP.c Bluetooth.c Initial.c
  group HARDWARE
    ../HARDWARE/FFT/: fft.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/job/: job1.c
  group OTA
    ../USE_SRC/: USE_JOB1.c modbus_crc.c
    ../USE_INC/IAP/: iap.c
    ../USE_INC/STMFLASH/: stmflash.c
    ../USE_INC/sys/: sys.c
software components: CMSIS:CORE 4.3.0
